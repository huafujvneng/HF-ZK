# Keil uVision project tm4c.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123BE6PZ Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: tm4c-led +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C123BE6PZ TARGET_IS_TM4C123_RA3
  c include: .\inc;.\application;..\demo0406;.;..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s
    ./startup/: system_TM4C123.c
  group application
    ./application/: eeprominit.c gpioinit.c gui.c infrared.c led_display.c main.c modbus_rtu.c speaker.c
  group driverlib
    ./lib/: driverlib.lib
  group utils
    ./utils/: uartstdio.c
  group myinc
    ./myinc/: mystring.c mystring.h crc.c crc.h
  group headfiles
    ./headfiles/: basicdefine.h eeprominit.h gpioinit.h gui.h infrared.h led_display.h modbus_rtu.h speaker.h
